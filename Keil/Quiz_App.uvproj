# Keil uVision project Quiz_App.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Quiz_App +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    E:/VIT/Sem5/Courses/Microcontrollers and its Applications/Project/Proteus/: Quiz_App.c
